# Keil uVision project Project_18-19.uvproj, settings and files
target Project_18-19 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project_18-19
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD  USE_STDPERIPH_DRIVER
  c include: .\src\drivers\STM32F10x_StdPeriph_Driver\inc;.\src\drivers\STM32F10x_StdPeriph_Driver\src;.\src\drivers;.\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System files
    ./src/: Retarget.c
    ./src/drivers/: stm32f10x_it.c
  group Configuration
    ./src/drivers/: RTX_Config.c startup_stm32f10x_md.s system_stm32f10x.c
  group Source files
    ./src/: stm32f10x_conf.h main.c TaskPriorities.h SimulatorTask.h SimulatorTask.c
    ./src/drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
